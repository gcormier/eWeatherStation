# Repository gcormier/eWeatherStation

File readme.md:

# eWeatherstation
eWeatherstation is a simple weather station with a twist

1. It has an onboard temperature/humidity sensor
2. It can receive RF signals from nearby sensors such as the AcuRite 06002RM to display the actual outdoor temperature

It is powered by an ESP32, and has support for a LiPo battery and charging circuitry via Micro USB.

## Todo list
- [ ] 3D-Printed Housing
- [ ] Make UI look good
- [ ] Hardware revision to use esp32buddy programmer

## KiCad design pcb/eWeatherStation.kicad_pcb

Parts:
C1, C3: 1uF; C_1206_3216Metric
C2: 0.1uF; C_1206_3216Metric
C4, C10: 4.7uF; C_1206_3216Metric
C9: 10uF; C_1206_3216Metric
J2: USB_B_Micro; USB_Micro-B_Molex-105133-0001
J3: CASTELLATION; PinHeader_1x08_P2.54mm_Vertical
J4: 1S_BATTERY; JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal
J5: eflashy32; PinHeader_1x06_P2.54mm_Vertical
Q2: DMC2053UVT; TSOT-23-6
R2, R5: 10k; R_1206_3216Metric
R3: 470k; R_1206_3216Metric
R4, R6, R14: 150k; R_1206_3216Metric
R8: 100k; R_1206_3216Metric
R_CHG1: 2k2; R_1206_3216Metric
U1: TLV75533PDBV; SOT-23-5
U2: ESP32-S2-WROVER
U4: MCP73831-2-OT; SOT-23-5

Connections:
+3V3: C3.1, C9.2, J5.4, R8.2, R14.2, U1.5, U2.2 (3V3)
+BATT: C1.2, C10.2, J4.2, Q2.2 (S), R3.2, R5.1, U1.1, U1.3, U4.3 (VBAT)
/ADC_BATT: R2.2, U2.8 (IO05)
/CHG_STAT: R14.1, U2.10 (IO07), U4.1 (STAT)
/DISPLAY_ENABLE: Q2.1 (G), R6.1, U2.35 (IO41)
/EN: J5.5, R8.1, U2.41 (EN)
/GPIO0: J5.6, U2.3 (IO00)
/RXD: J5.3, U2.38 (RXD0)
/TXD: J5.2, U2.37 (TXD0)
/eBUSY: J3.8, U2.14 (IO11)
/eCLK: J3.4, U2.30 (IO36)
/eCS: J3.5, U2.28 (IO34)
/eDC: J3.6, U2.16 (IO13)
/eDIN: J3.3, U2.29 (IO35)
/eRST: J3.7, U2.18 (IO15)
GND: C1.1, C2.2, C3.2, C4.1, C9.1, C10.1, J2.5 (GND), J3.2, J4.1, J5.1, Q2.5 (S), R4.2, R6.2, R_CHG1.1, U1.2, U2.1 (GND), U2.26 (GND), U2.42 (GND), U2.43 (GND), U4.2 (VSS)
unnamed: C2.1, R2.1, R3.1, R4.1
unnamed: J3.1, Q2.4 (D)
unnamed: Q2.3 (G), Q2.6 (D), R5.2
unnamed: R_CHG1.2, U4.5 (PROG)
VBUS: C4.2, J2.1 (VBUS), U4.4 (VDD)

Notes on the sheet:
4.5V will give about 1.09V - just under the ESP32 1.1V ADC maximum input
Programming
3.3V Regulation
ADC Dividers
1000/R_CHG = 450mA
Charging

Board: 2 copper layers, 48.8 x 48.0 mm, 22 parts (0 on the bottom side), 21 nets.

## Commit log

2020-07-10 initial
2021-01-17 new wave
2021-03-22 newdesign
2021-09-30 new code
